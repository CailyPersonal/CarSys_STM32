# Keil uVision project CarSys.uvprojx, settings and files
target CarSys (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CarSys +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,TEMP_SHOW_MODE
  c include: .\Library\CMSIS\CM3\CoreSupport;.\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Library\STM32F10x_StdPeriph_Driver\inc;.\user\api;.\user\driver;.\user\function;.\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group lib
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group driver
    ./user/driver/: COMCommunicate.c stm32f10x_it.c WheelCtrl.c PublicDataCtrl.c Time.c ObstacleDeal.c
  group api
    ./user/api/: WirelessConnect.c CarRunCtrl.c GeneralCtrl.c DirectionModel.c
  group function
    ./user/function/: main.c Functions.c KernelProcess.c
  group notice
    ./user/: notice.txt
